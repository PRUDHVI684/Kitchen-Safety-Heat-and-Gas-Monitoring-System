# Keil uVision project kichen_safety_project.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2148 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: kichen_safety_project +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: Startup.s project_sample.c RTC_EDIT.c ADC.c delay.c interupt_project.c KPM.c LCD.c RTC1.h MACRO_DEFINES.h LCD_COMMANDS.h LCD_DEFINES.h LCD.h KPM_defines.h kpm.h myADC.h RTC_TEST.c LM35.c LM35.h Edit_time.c main.c
